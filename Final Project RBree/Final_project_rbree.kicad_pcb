# Repository Matthewtcf/RBRee-final-project

## KiCad design Final Project RBree/Final_project_rbree.kicad_pcb

Parts:
C1: 0.1uF; C_1206_3216Metric
C2: 10n; C_1206_3216Metric
C3, C6, C7: 100n; C_1206_3216Metric
C4: 1uF; C_1206_3216Metric
C5: 2.2uF; C_1206_3216Metric
C8: 1u; C_1206_3216Metric
Conn_01x1: Conn_01x06; JST_VH_B6P-VH_1x06_P3.96mm_Vertical
D1: 12V; D_DO-35_SOD27_P7.62mm_Horizontal
D2: D; D_SMA
D3: LED; LED_1206_3216Metric
F1: Fuse; Fuse_1206_3216Metric
H1, H2, H3, H4: MountingHole; MountingHole_3.2mm_M3
J1, J2: Conn_01x02_Pin; AMASS_XT60-M_1x02_P7.20mm_Vertical
LM1: LM311; SOIC-8_3.9x4.9mm_P1.27mm
Q1: MMBT3904; SOT-23
Q3: AO3401A; SOT-23
R1: 2k; R_1206_3216Metric
R2, R14: 10k; R_1206_3216Metric
R3, R5, R6, R7: 249k; R_1206_3216Metric
R4, R13: 2k2; R_1206_3216Metric
R8: 25k; R_1206_3216Metric
R9, R18, R19, R20: 1k; R_1206_3216Metric
R10, R11: 100; R_1206_3216Metric
R12: 1M; R_1206_3216Metric
R15, R16: 22k; R_1206_3216Metric
R17: 220k; R_1206_3216Metric
R21: 100k; R_1206_3216Metric
U1: TL431; TO-92
U2: LTV-817; DIP-4_W7.62mm
U3: B1212; Converter_DCDC_TRACO_TBA2-xxxx_Single_THT
U4: 2N7002; SOT-23
U7: NE555; SOIC-8_3.9x4.9mm_P1.27mm

Connections:
+12V: C3.1, C4.2, LM1.8 (V+), R4.2, R13.1, U3.6 (+Vout)
/RED+: Conn_01x1.3, Q3.3 (D)
/Vin: D1.1 (K), R7.2, R8.2, R10.2, R12.1
/Vref: C1.1, R1.1, R4.1, R11.2, U1.3 (K)
GLV+: Conn_01x1.1, D2.2 (A)
GLV-: C5.1, C6.1, C7.1, C8.1, Conn_01x1.4, Conn_01x1.5, Conn_01x1.6, Q1.3 (2), R14.2, R21.1, U3.2 (-Vin), U4.2 (S), U7.1 (GND)
GND: C1.2, C3.2, C4.1, D1.2 (A), J2.1, LM1.1 (GND), LM1.4 (V-), R2.2, R9.2, U1.2 (A), U3.4 (-Vout)
unnamed: D3.1 (K), R19.2
unnamed: F1.1, R3.1
unnamed: F1.2, J1.2
unnamed: C2.1, LM1.2 (+), R10.1
unnamed: C2.2, LM1.3 (-), R11.1
unnamed: LM1.5 (BAL), LM1.6 (STRB)
unnamed: LM1.7, R12.2, U2.2
unnamed: Q1.2 (1), R18.1
unnamed: Q1.1 (3), Q3.1 (G), R19.1, R20.1, R21.2
unnamed: R3.2, R5.1
unnamed: R5.2, R6.2
unnamed: R6.1, R7.1
unnamed: R8.1, R9.1
unnamed: R13.2, U2.1
unnamed: R1.2, R2.1, U1.1 (REF)
unnamed: R15.1, U4.3 (D), U7.4 (R)
unnamed: R14.1, U2.3, U4.1 (G)
unnamed: C7.2, U7.5 (CV)
unnamed: R16.1, R17.2, U7.7 (DIS)
unnamed: R18.2, U7.3 (Q)
unnamed: C8.2, R17.1, U7.2 (TR), U7.6 (THR)
VCC: C5.2, C6.2, D2.1 (K), D3.2 (A), Q3.2 (S), R15.2, R16.2, R20.2, U2.4, U3.1 (+Vin), U7.8 (VCC)

Notes on the sheet:
voltage splitter to split to slightly higher than 1.5V
Show clear area between 2 sides of the voltage on the board
Isolated power supply & TSAL light interconnect
Reference Voltage
~{VHI}
Input scaling
Only GLV should have ground plane
GLV
VHI
Vref is 1.5V
NE555 circuit

Board: 2 copper layers, 100.0 x 51.0 mm, 48 parts (0 on the bottom side), 29 nets.
